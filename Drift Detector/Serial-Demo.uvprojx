# Keil uVision project Serial-Demo.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.11.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Serial-Demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  link misc: --debug
  group Source
    ./src/: delay.c LEDs.c main.c queue.c timers.c UART.c GPS.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.5.0
